# Keil uVision project WIOLink_FRDM_K64.uvprojx, settings and files
target WIOLink_FRDM_K64 (5060020::V5.06 (build 20)::ARMCC)
  device: MK64FN1M0xxx12 Freescale
  pack: Keil.Kinetis_K60_DFP.1.4.0
  cpu: IROM(0x00000000,0x100000) IRAM(0x20000000,0x30000) IRAM2(0x1FFF0000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: WIOLink_FRDM_K64
  AfterMake: F:\install\softwares\Keil_v5\ARM\ARMCC\bin\fromelf.exe --bin -o ./BUILD/@L.bin ./BUILD/@L.axf
  c flags: Optim=1 uC99=1 v6Lang=1 v6LangP=1
  c define: MBED_APP_START=0x8000
  c misc: -DTARGET_KSDK2_MCUS -DDEVICE_RTC=1 -DDEVICE_SLEEP=1 -DTOOLCHAIN_object -DTOOLCHAIN_ARM_STD -DTARGET_KPSDK_CODE --split_sections -DMBED_BUILD_TIMESTAMP=1522292852.93 -DFEATURE_LWIP=1 -D__ASSERT_MSG -DTARGET_RELEASE -DTARGET_MCU_K64F --no_rtti -DARM_MATH_CM4 -DDEVICE_PORTINOUT=1 -DTARGET_FF_ARDUINO -c -DTARGET_RTOS_M4_M7 -DDEVICE_SPISLAVE=1 -DDEVICE_PORTOUT=1 -DDEVICE_FLASH=1 -DDEVICE_STDIO_MESSAGES=1 -DDEVICE_ANALOGOUT=1 -DTARGET_LIKE_MBED -DDEVICE_SERIAL_FC=1 --cpu=Cortex-M4.fp -DTARGET_FRDM -DFEATURE_STORAGE=1 -DTARGET_LIKE_CORTEX_M4 -D__CORTEX_M4 -DTARGET_CORTEX_M -DDEVICE_SERIAL=1 -DTARGET_KPSDK_MCUS -DTARGET_Freescale -DDEVICE_I2C=1 --preinclude=mbed_config.h -DTARGET_CORTEX -DDEVICE_LOWPOWERTIMER=1 -DTARGET_MCUXpresso_MCUS -DTOOLCHAIN_ARM -DDEVICE_INTERRUPTIN=1 -DDEVICE_ANALOGIN=1 --no_depend_system_headers -DTARGET_UVISOR_UNSUPPORTED -D__CMSIS_RTOS --md -DDEVICE_PWMOUT=1 -DDEVICE_SERIAL_ASYNCH=1 --gnu -DDEVICE_TRNG=1 --apcs=interwork -DDEVICE_SPI=1 -D__MBED__=1 -DTARGET_K64F -DCPU_MK64FN1M0VMD12 -DDEVICE_STORAGE=1 -DDEVICE_PORTIN=1 -DTARGET_M4 -D__FPU_PRESENT=1 -DDEVICE_I2CSLAVE=1 -DFSL_RTOS_MBED -DDEVICE_SPI_ASYNCH=1 -D__MBED_CMSIS_RTOS_CM
  c include: .;mbed-os/.;mbed-os/features;mbed-os/features/frameworks;mbed-os/features/frameworks/greentea-client;mbed-os/features/frameworks/greentea-client/greentea-client;mbed-os/features/frameworks/greentea-client/source;mbed-os/features/frameworks/unity;mbed-os/features/frameworks/unity/source;mbed-os/features/frameworks/unity/unity;mbed-os/features/frameworks/utest;mbed-os/features/frameworks/utest/source;mbed-os/features/frameworks/utest/utest;mbed-os/features/mbedtls;mbed-os/features/mbedtls/importer;mbed-os/features/mbedtls/inc;mbed-os/features/mbedtls/inc/mbedtls;mbed-os/features/mbedtls/src;mbed-os/features/mbedtls/platform;mbed-os/features/mbedtls/platform/inc;mbed-os/features/mbedtls/platform/src;mbed-os/features/mbedtls/targets;mbed-os/features/nanostack;mbed-os/features/storage;mbed-os/features/netsocket;mbed-os/features/netsocket/cellular;mbed-os/features/netsocket/cellular/generic_modem_driver;mbed-os/features/netsocket/cellular/utils;mbed-os/features/filesystem;mbed-os/features/filesystem/bd;mbed-os/features/filesystem/fat;mbed-os/features/filesystem/fat/ChaN;mbed-os/features/filesystem/littlefs;mbed-os/features/filesystem/littlefs/littlefs;mbed-os/cmsis;mbed-os/cmsis/TARGET_CORTEX_M;mbed-os/drivers;mbed-os/events;mbed-os/events/equeue;mbed-os/rtos;mbed-os/rtos/TARGET_CORTEX;mbed-os/rtos/TARGET_CORTEX/rtx4;mbed-os/rtos/TARGET_CORTEX/rtx5;mbed-os/rtos/TARGET_CORTEX/rtx5/Include;mbed-os/rtos/TARGET_CORTEX/rtx5/RTX;mbed-os/rtos/TARGET_CORTEX/rtx5/RTX/Config;mbed-os/rtos/TARGET_CORTEX/rtx5/RTX/Include;mbed-os/rtos/TARGET_CORTEX/rtx5/RTX/Source;mbed-os/rtos/TARGET_CORTEX/rtx5/RTX/Source/TOOLCHAIN_ARM;mbed-os/rtos/TARGET_CORTEX/rtx5/RTX/Source/TOOLCHAIN_ARM/TARGET_RTOS_M4_M7;mbed-os/rtos/TARGET_CORTEX/rtx5/Source;mbed-os/hal;mbed-os/hal/storage_abstraction;mbed-os/platform;mbed-os/targets;mbed-os/targets/TARGET_Freescale;mbed-os/targets/TARGET_Freescale/TARGET_MCUXpresso_MCUS;mbed-os/targets/TARGET_Freescale/TARGET_MCUXpresso_MCUS/TARGET_MCU_K64F;mbed-os/targets/TARGET_Freescale/TARGET_MCUXpresso_MCUS/TARGET_MCU_K64F/TARGET_FRDM;mbed-os/targets/TARGET_Freescale/TARGET_MCUXpresso_MCUS/TARGET_MCU_K64F/device;mbed-os/targets/TARGET_Freescale/TARGET_MCUXpresso_MCUS/TARGET_MCU_K64F/device/TOOLCHAIN_ARM_STD;mbed-os/targets/TARGET_Freescale/TARGET_MCUXpresso_MCUS/TARGET_MCU_K64F/drivers;mbed-os/targets/TARGET_Freescale/TARGET_MCUXpresso_MCUS/api;mbed-os/features/FEATURE_LWIP;mbed-os/features/FEATURE_LWIP/lwip-interface;mbed-os/features/FEATURE_LWIP/lwip-interface/lwip-eth;mbed-os/features/FEATURE_LWIP/lwip-interface/lwip-eth/arch;mbed-os/features/FEATURE_LWIP/lwip-interface/lwip-eth/arch/TARGET_Freescale;mbed-os/features/FEATURE_LWIP/lwip-interface/lwip-eth/arch/TARGET_Freescale/TARGET_K64F;mbed-os/features/FEATURE_LWIP/lwip-interface/lwip-sys;mbed-os/features/FEATURE_LWIP/lwip-interface/lwip-sys/arch;mbed-os/features/FEATURE_LWIP/lwip-interface/lwip;mbed-os/features/FEATURE_LWIP/lwip-interface/lwip/src;mbed-os/features/FEATURE_LWIP/lwip-interface/lwip/src/api;mbed-os/features/FEATURE_LWIP/lwip-interface/lwip/src/core;mbed-os/features/FEATURE_LWIP/lwip-interface/lwip/src/core/ipv4;mbed-os/features/FEATURE_LWIP/lwip-interface/lwip/src/core/ipv6;mbed-os/features/FEATURE_LWIP/lwip-interface/lwip/src/include;mbed-os/features/FEATURE_LWIP/lwip-interface/lwip/src/include/lwip;mbed-os/features/FEATURE_LWIP/lwip-interface/lwip/src/include/lwip/priv;mbed-os/features/FEATURE_LWIP/lwip-interface/lwip/src/include/lwip/prot;mbed-os/features/FEATURE_LWIP/lwip-interface/lwip/src/include/netif;mbed-os/features/FEATURE_LWIP/lwip-interface/lwip/src/include/netif/ppp;mbed-os/features/FEATURE_LWIP/lwip-interface/lwip/src/include/netif/ppp/polarssl;mbed-os/features/FEATURE_LWIP/lwip-interface/lwip/src/netif;mbed-os/features/FEATURE_LWIP/lwip-interface/lwip/src/netif/ppp;mbed-os/features/FEATURE_LWIP/lwip-interface/lwip/src/netif/ppp/polarssl;mbed-os/features/storage/FEATURE_STORAGE;mbed-os/features/storage/FEATURE_STORAGE/cfstore;mbed-os/features/storage/FEATURE_STORAGE/cfstore/configuration-store;mbed-os/features/storage/FEATURE_STORAGE/cfstore/doc;mbed-os/features/storage/FEATURE_STORAGE/cfstore/doc/design;mbed-os/features/storage/FEATURE_STORAGE/cfstore/doc/design/pics;mbed-os/features/storage/FEATURE_STORAGE/cfstore/doc/design/umlet;mbed-os/features/storage/FEATURE_STORAGE/cfstore/doc/project;mbed-os/features/storage/FEATURE_STORAGE/cfstore/source;mbed-os/features/storage/FEATURE_STORAGE/flash-journal;mbed-os/features/storage/FEATURE_STORAGE/flash-journal/flash-journal-strategy-sequential;mbed-os/features/storage/FEATURE_STORAGE/storage-volume-manager;mbed-os/features/storage/FEATURE_STORAGE/storage-volume-manager/source;mbed-os/features/storage/FEATURE_STORAGE/storage-volume-manager/storage-volume-manager;.\sensor\include;.\cJSON;..\WIOLink_FRDM_K64_mbed5.7;.\md5;.\crc16;.\ota
  asm misc: --cpreproc --cpreproc_opts=-D__ASSERT_MSG,-D__CORTEX_M4,-DCPU_MK64FN1M0VMD12,-DARM_MATH_CM4,-D__FPU_PRESENT=1,-D__MBED_CMSIS_RTOS_CM,-D__CMSIS_RTOS,-DFSL_RTOS_MBED
  memory RVCT4: ROM 0x0 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x30000
  memory RVCT10: RAM 0x1fff0000 size 0x10000
  scatter file: mbed-os/targets/TARGET_Freescale/TARGET_MCUXpresso_MCUS/TARGET_MCU_K64F/device/TOOLCHAIN_ARM_STD/MK64FN1M0xxx12.sct
  link misc: --show_full_path
  group WIOLink_FRDM_K64
    ./: main.cpp mbed_config.h
    ./: main1.cpp dev.cpp dev.h UserConfig.h
  group mbed-os
    mbed-os/features/mbedtls/src/: aes.c aesni.c arc4.c asn1parse.c asn1write.c base64.c bignum.c blowfish.c camellia.c ccm.c certs.c cipher.c cipher_wrap.c cmac.c ctr_drbg.c debug.c des.c dhm.c ecdh.c ecdsa.c ecjpake.c ecp.c ecp_curves.c entropy.c entropy_poll.c error.c gcm.c havege.c hmac_drbg.c md.c md2.c md4.c md5.c md_wrap.c memory_buffer_alloc.c net_sockets.c oid.c padlock.c pem.c pk.c pk_wrap.c pkcs11.c pkcs12.c pkcs5.c pkparse.c pkwrite.c platform.c ripemd160.c rsa.c sha1.c sha256.c sha512.c ssl_cache.c ssl_ciphersuites.c ssl_cli.c ssl_cookie.c ssl_srv.c ssl_ticket.c ssl_tls.c threading.c timing.c version.c version_features.c x509.c x509_create.c x509_crl.c x509_crt.c x509_csr.c x509write_crt.c x509write_csr.c xtea.c
    mbed-os/features/mbedtls/inc/mbedtls/: aes.h aesni.h arc4.h asn1.h asn1write.h base64.h bignum.h blowfish.h bn_mul.h camellia.h ccm.h certs.h check_config.h cipher.h cipher_internal.h cmac.h compat-1.3.h config-no-entropy.h config.h ctr_drbg.h debug.h des.h dhm.h ecdh.h ecdsa.h ecjpake.h ecp.h ecp_internal.h entropy.h entropy_poll.h error.h gcm.h havege.h hmac_drbg.h md.h md2.h md4.h md5.h md_internal.h memory_buffer_alloc.h net.h net_sockets.h oid.h padlock.h pem.h pk.h pk_internal.h pkcs11.h pkcs12.h pkcs5.h platform.h platform_time.h ripemd160.h rsa.h sha1.h sha256.h sha512.h ssl.h ssl_cache.h ssl_ciphersuites.h ssl_cookie.h ssl_internal.h ssl_ticket.h threading.h timing.h version.h x509.h x509_crl.h x509_crt.h x509_csr.h xtea.h
    mbed-os/drivers/: AnalogIn.cpp AnalogIn.h AnalogOut.h BusIn.cpp BusIn.h BusInOut.cpp BusInOut.h BusOut.cpp BusOut.h CAN.cpp CAN.h DigitalIn.h DigitalInOut.h DigitalOut.h Ethernet.cpp Ethernet.h FlashIAP.cpp FlashIAP.h I2C.cpp I2C.h I2CSlave.cpp I2CSlave.h InterruptIn.cpp InterruptIn.h InterruptManager.cpp InterruptManager.h LowPowerTicker.h LowPowerTimeout.h LowPowerTimer.h PortIn.h PortInOut.h PortOut.h PwmOut.h RawSerial.cpp RawSerial.h Serial.cpp Serial.h SerialBase.cpp SerialBase.h SPI.cpp SPI.h SPISlave.cpp SPISlave.h Ticker.cpp Ticker.h Timeout.cpp Timeout.h Timer.cpp Timer.h TimerEvent.cpp TimerEvent.h UARTSerial.cpp UARTSerial.h
    mbed-os/targets/TARGET_Freescale/TARGET_MCUXpresso_MCUS/api/: analogin_api.c analogout_api.c dma_api.c dma_api_hal.h flash_api.c gpio_api.c gpio_irq_api.c gpio_object.h i2c_api.c lp_ticker.c objects.h PeripheralPins.h pinmap.c port_api.c PortNames.h rtc_api.c sleep.c
    mbed-os/hal/: analogin_api.h analogout_api.h buffer.h can_api.h can_helper.h dma_api.h emac_api.h ethernet_api.h flash_api.h gpio_api.h gpio_irq_api.h i2c_api.h lp_ticker_api.h mbed_flash_api.c mbed_gpio.c mbed_lp_ticker_api.c mbed_pinmap_common.c mbed_sleep_manager.c mbed_ticker_api.c mbed_us_ticker_api.c pinmap.h port_api.h pwmout_api.h rtc_api.h serial_api.h sleep_api.h spi_api.h ticker_api.h trng_api.h us_ticker_api.h
    mbed-os/features/FEATURE_LWIP/lwip-interface/lwip/src/include/lwip/: api.h arch.h autoip.h debug.h def.h dhcp.h dhcp6.h dns.h err.h etharp.h ethip6.h icmp.h icmp6.h igmp.h inet.h inet_chksum.h init.h ip.h ip4.h ip4_addr.h ip4_frag.h ip6.h ip6_addr.h ip6_frag.h ip_addr.h lwip_errno.h mem.h memp.h mld6.h nd6.h netbuf.h netdb.h netif.h netifapi.h opt.h pbuf.h raw.h sio.h snmp.h sockets.h stats.h sys.h tcp.h tcpip.h timeouts.h udp.h
    mbed-os/features/FEATURE_LWIP/lwip-interface/lwip/src/include/lwip/priv/: api_msg.h memp_priv.h memp_std.h nd6_priv.h tcp_priv.h tcpip_priv.h
    mbed-os/features/netsocket/cellular/utils/: APN_db.h
    mbed-os/features/FEATURE_LWIP/lwip-interface/lwip/src/include/netif/ppp/polarssl/: arc4.h des.h md4.h md5.h sha1.h
    mbed-os/cmsis/TARGET_CORTEX_M/: arm_math.h cmsis_armcc.h cmsis_armclang.h cmsis_compiler.h cmsis_gcc.h cmsis_iccarm.h cmsis_version.h core_armv8mbl.h core_armv8mml.h core_cm0.h core_cm0plus.h core_cm23.h core_cm3.h core_cm33.h core_cm4.h core_cm7.h core_cmSecureAccess.h core_sc000.h core_sc300.h mpu_armv7.h mpu_armv8.h tz_context.h
    mbed-os/platform/: ATCmdParser.cpp ATCmdParser.h Callback.h CallChain.cpp CallChain.h CircularBuffer.h critical.h CriticalSectionLock.h CThunk.h DeepSleepLock.h DirHandle.h FileBase.cpp FileBase.h FileHandle.cpp FileHandle.h FileLike.h FilePath.cpp FilePath.h FileSystemHandle.cpp FileSystemHandle.h FileSystemLike.h FunctionPointer.h LocalFileSystem.cpp LocalFileSystem.h mbed_alloc_wrappers.cpp mbed_application.c mbed_application.h mbed_assert.c mbed_assert.h mbed_board.c mbed_critical.c mbed_critical.h mbed_debug.h mbed_error.c mbed_error.h mbed_interface.c mbed_interface.h mbed_mem_trace.cpp mbed_mem_trace.h mbed_mktime.c mbed_mktime.h mbed_poll.cpp mbed_poll.h mbed_preprocessor.h mbed_retarget.cpp mbed_retarget.h mbed_rtc_time.cpp mbed_rtc_time.h mbed_sdk_boot.c mbed_semihost_api.c mbed_semihost_api.h mbed_sleep.h mbed_stats.c mbed_stats.h mbed_toolchain.h mbed_wait_api.h mbed_wait_api_no_rtos.c mbed_wait_api_rtos.cpp NonCopyable.h platform.h PlatformMutex.h rtc_time.h semihost_api.h SingletonPtr.h sleep.h Stream.cpp Stream.h toolchain.h Transaction.h wait_api.h
    mbed-os/features/FEATURE_LWIP/lwip-interface/lwip/src/include/lwip/prot/: autoip.h dhcp.h dns.h etharp.h icmp.h icmp6.h igmp.h ip.h ip4.h ip6.h lwip_ethernet.h mld6.h nd6.h tcp.h udp.h
    mbed-os/features/filesystem/bd/: BlockDevice.h ChainingBlockDevice.cpp ChainingBlockDevice.h ExhaustibleBlockDevice.cpp ExhaustibleBlockDevice.h HeapBlockDevice.cpp HeapBlockDevice.h MBRBlockDevice.cpp MBRBlockDevice.h ObservingBlockDevice.cpp ObservingBlockDevice.h ProfilingBlockDevice.cpp ProfilingBlockDevice.h ReadOnlyBlockDevice.cpp ReadOnlyBlockDevice.h SlicingBlockDevice.cpp SlicingBlockDevice.h
    mbed-os/features/FEATURE_LWIP/lwip-interface/lwip-sys/arch/: cc.h lwip_checksum.c lwip_memcpy.c lwip_sys_arch.c perf.h sys_arch.h
    mbed-os/features/FEATURE_LWIP/lwip-interface/lwip/src/include/netif/ppp/: ccp.h chap-md5.h chap-new.h chap_ms.h eap.h ecp.h eui64.h fsm.h ipcp.h ipv6cp.h lcp.h magic.h mppe.h ppp.h ppp_impl.h ppp_opts.h pppapi.h pppcrypt.h pppdebug.h pppoe.h pppol2tp.h pppos.h upap.h vj.h
    mbed-os/features/netsocket/: CellularBase.h CellularInterface.h emac_stack_mem.h EthInterface.h MeshInterface.h NetworkInterface.cpp NetworkInterface.h NetworkStack.cpp NetworkStack.h nsapi.h nsapi_dns.cpp nsapi_dns.h nsapi_ppp.h nsapi_types.h Socket.cpp Socket.h SocketAddress.cpp SocketAddress.h TCPServer.cpp TCPServer.h TCPSocket.cpp TCPSocket.h UDPSocket.cpp UDPSocket.h WiFiAccessPoint.cpp WiFiAccessPoint.h WiFiInterface.h
    mbed-os/features/storage/FEATURE_STORAGE/cfstore/source/: cfstore_config.h cfstore_debug.h cfstore_fnmatch.c cfstore_fnmatch.h cfstore_list.h cfstore_svm.cpp cfstore_svm.h cfstore_test.c cfstore_test.h cfstore_utest.h cfstore_uvisor.h configuration_store.c
    mbed-os/targets/TARGET_Freescale/TARGET_MCUXpresso_MCUS/TARGET_MCU_K64F/device/: cmsis.h cmsis_nvic.h fsl_device_registers.h MK64F12.h MK64F12_features.h system_MK64F12.c system_MK64F12.h
    mbed-os/rtos/TARGET_CORTEX/rtx4/: cmsis_os.h cmsis_os1.c
    mbed-os/rtos/TARGET_CORTEX/rtx5/Include/: cmsis_os2.h os_tick.h
    mbed-os/rtos/: ConditionVariable.cpp ConditionVariable.h EventFlags.cpp EventFlags.h Kernel.cpp Kernel.h Mail.h MemoryPool.h Mutex.cpp Mutex.h Queue.h rtos.h rtos_idle.h RtosTimer.cpp RtosTimer.h Semaphore.cpp Semaphore.h Thread.cpp Thread.h
    mbed-os/features/storage/FEATURE_STORAGE/cfstore/configuration-store/: configuration_store.h
    mbed-os/targets/TARGET_Freescale/TARGET_MCUXpresso_MCUS/TARGET_MCU_K64F/TARGET_FRDM/: crc.c crc.h device.h fsl_clock_config.c fsl_clock_config.h fsl_phy.c fsl_phy.h mbed_overrides.c PeripheralNames.h PeripheralPins.c PinNames.h
    mbed-os/features/filesystem/: Dir.cpp Dir.h File.cpp File.h FileSystem.cpp FileSystem.h mbed_filesystem.h
    mbed-os/features/filesystem/fat/ChaN/: diskio.h ff.cpp ff.h ffconf.h ffunicode.cpp integer.h
    mbed-os/targets/TARGET_Freescale/TARGET_MCUXpresso_MCUS/TARGET_MCU_K64F/: dma_reqs.h peripheral_clock_defines.h pwmout_api.c serial_api.c spi_api.c storage_driver.c trng_api.c us_ticker.c
    mbed-os/hal/storage_abstraction/: Driver_Common.h Driver_Storage.h
    mbed-os/features/FEATURE_LWIP/lwip-interface/: emac_lwip.c emac_stack_lwip.cpp eth_arch.h EthernetInterface.cpp EthernetInterface.h lwip_stack.c lwip_stack.h lwipopts.h ppp_lwip.cpp ppp_lwip.h
    mbed-os/events/equeue/: equeue.c equeue.h equeue_mbed.cpp equeue_platform.h equeue_posix.c
    mbed-os/features/FEATURE_LWIP/lwip-interface/lwip/src/include/netif/: etharp.h lowpan6.h lowpan6_opts.h lwip_ethernet.h slipif.h
    mbed-os/events/: Event.h EventQueue.cpp EventQueue.h mbed_events.h mbed_shared_queues.cpp mbed_shared_queues.h
    mbed-os/features/filesystem/fat/: FATFileSystem.cpp FATFileSystem.h
    mbed-os/features/storage/FEATURE_STORAGE/flash-journal/: flash_journal.h
    mbed-os/features/storage/FEATURE_STORAGE/flash-journal/flash-journal-strategy-sequential/: flash_journal_crc.c flash_journal_crc.h flash_journal_private.h flash_journal_strategy_sequential.h strategy.c support_funcs.c support_funcs.h
    mbed-os/targets/TARGET_Freescale/TARGET_MCUXpresso_MCUS/TARGET_MCU_K64F/drivers/: fsl_adc16.c fsl_adc16.h fsl_clock.c fsl_clock.h fsl_cmp.c fsl_cmp.h fsl_cmt.c fsl_cmt.h fsl_common.h fsl_crc.c fsl_crc.h fsl_dac.c fsl_dac.h fsl_dmamux.c fsl_dmamux.h fsl_dspi.c fsl_dspi.h fsl_dspi_edma.c fsl_dspi_edma.h fsl_edma.c fsl_edma.h fsl_enet.c fsl_enet.h fsl_ewm.c fsl_ewm.h fsl_flash.c fsl_flash.h fsl_flexbus.c fsl_flexbus.h fsl_flexcan.c fsl_flexcan.h fsl_ftm.c fsl_ftm.h fsl_gpio.c fsl_gpio.h fsl_i2c.c fsl_i2c.h fsl_i2c_edma.c fsl_i2c_edma.h fsl_llwu.c fsl_llwu.h fsl_lptmr.c fsl_lptmr.h fsl_mpu.c fsl_mpu.h fsl_pdb.c fsl_pdb.h fsl_pit.c fsl_pit.h fsl_pmc.c fsl_pmc.h fsl_port.h fsl_rcm.c fsl_rcm.h fsl_rnga.c fsl_rnga.h fsl_rtc.c fsl_rtc.h fsl_sai.c fsl_sai.h fsl_sai_edma.c fsl_sai_edma.h fsl_sdhc.c fsl_sdhc.h fsl_sim.c fsl_sim.h fsl_smc.c fsl_smc.h fsl_uart.c fsl_uart.h fsl_uart_edma.c fsl_uart_edma.h fsl_vref.c fsl_vref.h fsl_wdog.c fsl_wdog.h
    mbed-os/targets/TARGET_Freescale/TARGET_MCUXpresso_MCUS/: fsl_common.c
    mbed-os/features/frameworks/greentea-client/source/: greentea_metrics.cpp greentea_serial.cpp greentea_test_env.cpp
    mbed-os/features/frameworks/greentea-client/greentea-client/: greentea_metrics.h greentea_serial.h test_env.h
    mbed-os/features/FEATURE_LWIP/lwip-interface/lwip-eth/arch/TARGET_Freescale/TARGET_K64F/: hardware_init_MK64F12.c
    mbed-os/rtos/TARGET_CORTEX/rtx5/RTX/Source/TOOLCHAIN_ARM/TARGET_RTOS_M4_M7/: irq_cm4f.S
    mbed-os/features/FEATURE_LWIP/lwip-interface/lwip-eth/arch/TARGET_Freescale/: k64f_emac.c k64f_emac_config.h lwipopts_conf.h
    mbed-os/features/filesystem/littlefs/littlefs/: lfs.c lfs.h lfs_util.c lfs_util.h
    mbed-os/features/filesystem/littlefs/: LittleFileSystem.cpp LittleFileSystem.h
    mbed-os/features/FEATURE_LWIP/lwip-interface/lwip/src/api/: lwip_api_lib.c lwip_api_msg.c lwip_err.c lwip_netbuf.c lwip_netdb.c lwip_netifapi.c lwip_sockets.c lwip_tcpip.c
    mbed-os/features/FEATURE_LWIP/lwip-interface/lwip/src/netif/ppp/polarssl/: lwip_arc4.c lwip_des.c lwip_md4.c lwip_md5.c lwip_sha1.c
    mbed-os/features/FEATURE_LWIP/lwip-interface/lwip/src/netif/ppp/: lwip_auth.c lwip_ccp.c lwip_chap-md5.c lwip_chap-new.c lwip_chap_ms.c lwip_demand.c lwip_eap.c lwip_ecp.c lwip_eui64.c lwip_fsm.c lwip_ipcp.c lwip_ipv6cp.c lwip_lcp.c lwip_magic.c lwip_mppe.c lwip_multilink.c lwip_ppp.c lwip_pppapi.c lwip_pppcrypt.c lwip_pppoe.c lwip_pppol2tp.c lwip_pppos.c lwip_upap.c lwip_utils.c lwip_vj.c
    mbed-os/features/FEATURE_LWIP/lwip-interface/lwip/src/core/ipv4/: lwip_autoip.c lwip_dhcp.c lwip_etharp.c lwip_icmp.c lwip_igmp.c lwip_ip4.c lwip_ip4_addr.c lwip_ip4_frag.c
    mbed-os/features/FEATURE_LWIP/lwip-interface/lwip/src/core/: lwip_def.c lwip_dns.c lwip_inet_chksum.c lwip_init.c lwip_ip.c lwip_mem.c lwip_memp.c lwip_netif.c lwip_pbuf.c lwip_raw.c lwip_stats.c lwip_sys.c lwip_tcp.c lwip_tcp_in.c lwip_tcp_out.c lwip_timeouts.c lwip_udp.c
    mbed-os/features/FEATURE_LWIP/lwip-interface/lwip/src/core/ipv6/: lwip_dhcp6.c lwip_ethip6.c lwip_icmp6.c lwip_inet6.c lwip_ip6.c lwip_ip6_addr.c lwip_ip6_frag.c lwip_mld6.c lwip_nd6.c
    mbed-os/features/FEATURE_LWIP/lwip-interface/lwip/src/netif/: lwip_ethernet.c lwip_ethernetif.c lwip_lowpan6.c
    mbed-os/features/FEATURE_LWIP/lwip-interface/lwip-sys/: lwip_random.c lwip_random.h lwip_tcp_isn.c lwip_tcp_isn.h
    mbed-os/features/frameworks/utest/: mbed-utest-shim.cpp
    mbed-os/: mbed.h
    mbed-os/rtos/TARGET_CORTEX/: mbed_boot.c mbed_rtos1_types.h mbed_rtos_storage.h mbed_rtx_conf.h mbed_rtx_handlers.c mbed_rtx_idle.cpp
    mbed-os/targets/TARGET_Freescale/: mbed_rtx.h
    mbed-os/features/mbedtls/platform/src/: mbed_trng.c
    mbed-os/features/netsocket/cellular/: onboard_modem_api.h
    mbed-os/features/netsocket/cellular/generic_modem_driver/: OnboardCellularInterface.cpp OnboardCellularInterface.h PPPCellularInterface.cpp PPPCellularInterface.h UARTCellularInterface.cpp UARTCellularInterface.h
    mbed-os/rtos/TARGET_CORTEX/rtx5/Source/: os_systick.c os_tick_ptim.c
    mbed-os/features/mbedtls/platform/inc/: platform_mbed.h
    mbed-os/rtos/TARGET_CORTEX/rtx5/RTX/Source/: rt_OsEventObserver.c rt_OsEventObserver.h rtx_core_c.h rtx_core_ca.h rtx_core_cm.h rtx_delay.c rtx_evflags.c rtx_evr.c rtx_kernel.c rtx_lib.c rtx_lib.h rtx_memory.c rtx_mempool.c rtx_msgqueue.c rtx_mutex.c rtx_semaphore.c rtx_system.c rtx_thread.c rtx_timer.c
    mbed-os/rtos/TARGET_CORTEX/rtx5/RTX/Config/: RTX_Config.c RTX_Config.h
    mbed-os/rtos/TARGET_CORTEX/rtx5/RTX/Include/: rtx_evr.h rtx_os.h
    mbed-os/targets/TARGET_Freescale/TARGET_MCUXpresso_MCUS/TARGET_MCU_K64F/device/TOOLCHAIN_ARM_STD/: startup_MK64F12.S
    mbed-os/features/storage/FEATURE_STORAGE/storage-volume-manager/source/: storage_volume.cpp storage_volume_manager.cpp
    mbed-os/features/storage/FEATURE_STORAGE/storage-volume-manager/storage-volume-manager/: storage_volume_manager.h
    mbed-os/features/frameworks/unity/source/: unity.c
    mbed-os/features/frameworks/unity/unity/: unity.h unity_config.h unity_internals.h
    mbed-os/features/frameworks/utest/source/: unity_handler.cpp utest_case.cpp utest_default_handlers.cpp utest_greentea_handlers.cpp utest_harness.cpp utest_shim.cpp utest_stack_trace.cpp utest_types.cpp
    mbed-os/features/frameworks/utest/utest/: unity_handler.h utest.h utest_case.h utest_default_handlers.h utest_harness.h utest_scheduler.h utest_serial.h utest_shim.h utest_specification.h utest_stack_trace.h utest_types.h
  group Sensor_Driver
    ./sensor/drivers/: WIO_NCP5623.cpp WIO_OLED.cpp WIO_HDC1050.cpp WIO_VEML6075.cpp WIO_SPL06.cpp WIO_ADXL345.cpp
  group cJSON
    ./cJSON/: cJSON.cpp cJSON.h
  group crc16
    ./crc16/: lib_crc16.cpp lib_crc16.h
  group md5
    ./md5/: md5Std.cpp md5Std.h
  group ota
    ./ota/: ota.cpp ota.h
